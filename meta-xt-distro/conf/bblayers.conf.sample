## meta-xt-distro/conf/bblayers.conf.sample
```bitbake
BBPATH = "${TOPDIR}"
BBFILES ?= ""

BBLAYERS ?= " \
  ##OEROOT##/meta \
  ##OEROOT##/meta-xt-distro \
  "
```
